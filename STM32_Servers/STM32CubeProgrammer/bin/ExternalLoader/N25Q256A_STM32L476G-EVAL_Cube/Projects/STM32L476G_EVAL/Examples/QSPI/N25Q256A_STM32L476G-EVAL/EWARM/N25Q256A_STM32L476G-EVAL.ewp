# IAR project N25Q256A_STM32L476G-EVAL.ewp, settings and files
configuration STM32L476G_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L476G_EVAL_REVB; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L476G_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N25Q256A_STM32L476G-EVAL.hex
  postbuild: cmd.exe /C copy "N25Q256A_STM32L476G-EVAL\Exe\N25Q256A_STM32L476G-EVAL.out" "..\..\..\..\..\..\..\N25Q256A_STM32L476G-EVAL.stldr"
  ILINK.IlinkOutputFile: N25Q256A_STM32L476G-EVAL.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c
  group Example/EWARM/User
    ../Src/: Dev_Inf.c Loader_Src.c stm32l4xx_hal_msp.c stm32l4xx_it.c
