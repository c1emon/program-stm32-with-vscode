<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Start.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Start</project>
        <configuration>Flash Bin</configuration>
      </member>
      <member>
        <project>Start</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>Start</project>
        <configuration>RAM_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


